# Keil uVision project CentralComputer.uvprojx, settings and files
target CComputer (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: -AT32F403AVGT7 ArteryTek
  pack: ArteryTek.AT32F403A_407_DFP.2.0.7
  cpu: IRAM(0x20000000,0x38000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: CentralComputer +hex
  c flags: Optim=1 oTime=1 OneElfS=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=2
  c define: AT32F403AVGT7,LIBRARY_VERSION
  c include: ..\uinc;..\uint;..\..\MYLibrary\INC;..\..\MYLibrary\uint;..\..\MYLibrary\Usartinit\init;..\..\MYLibrary\AT32F4_Libraries\AT32F4xx_StdPeriph_Driver\inc;..\..\MYLibrary\AT32F4_Libraries\CMSIS\CM4\DeviceSupport;..\..\MYLibrary\AT32F4_Libraries\CMSIS\CM4\CoreSupport
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group StartUp
    ../../MYLibrary/AT32F4_Libraries/CMSIS/CM4/DeviceSupport/: system_at32f4xx.c
    ../../MYLibrary/AT32F4_Libraries/CMSIS/CM4/DeviceSupport/startup/mdk/: startup_at32f403avgt7.s
  group Libraries
    ../../MYLibrary/AT32F4_Libraries/AT32F4xx_StdPeriph_Driver/src/: at32f4xx_acc.c at32f4xx_adc.c at32f4xx_bkp.c at32f4xx_can.c at32f4xx_comp.c at32f4xx_crc.c at32f4xx_dac.c at32f4xx_dbgmcu.c at32f4xx_dma.c at32f4xx_ertc.c at32f4xx_eth.c at32f4xx_exti.c at32f4xx_flash.c at32f4xx_gpio.c at32f4xx_gpio_ex.c at32f4xx_i2c.c at32f4xx_iwdg.c at32f4xx_pwr.c at32f4xx_rcc.c at32f4xx_rtc.c at32f4xx_sdio.c at32f4xx_spi.c at32f4xx_syscfg.c at32f4xx_tim.c at32f4xx_usart.c at32f4xx_wwdg.c at32f4xx_xmc.c misc.c
  group Head
    ../uint/: userint.h usermain.h
  group umain
    ../usrc/: at32f4xx_it.c main.c usermain.c
  group Work
    ../usrc/: TXD_RXDcomm.c
    ../../MYLibrary/SCR/: W25Q128.c DS18B20.c SofSPI.c Sensor.c
  group COM
    ../../MYLibrary/Usartinit/: SLusartinit.c SLuserUSART.c USendList.c
